# Keil uVision project QuadVolucer2.uvproj, settings and files
target STM32F103VC (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: QuadVolucer2 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\inc;..\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./src/: ADC.c eeprom.c GPIO.c main.c stm32f10x_it.c I2C.c rcdsl.c mixer.c TIM.c UART.c CAN.c mpx_rc.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Lib_V3.4.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_sdio.c misc.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_i2c.c stm32f10x_usart.c stm32f10x_can.c
  group CMSIS
    ./: system_stm32f10x.c
    ../STM32F10x_StdPeriph_Lib_V3.4.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group RVMDK
    ../STM32F10x_StdPeriph_Lib_V3.4.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
