# Keil uVision project bldc_can.uvproj, settings and files
target STM32F103VC (ARM-ADS)
  device: STM32F103C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bldc_can
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;..\STM32F10x_StdPeriph_Lib_V3.2.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.2.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Lib_V3.2.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group user
    ./src/: ADC.c beep.c bemf.c CAN.c Com_TIM.c GPIO.c main.c pwm_states.c pwm_TIM.c startup.c stm32f10x_it.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Lib_V3.2.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_fsmc.c
  group CMSIS
    ../STM32F10x_StdPeriph_Lib_V3.2.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../STM32F10x_StdPeriph_Lib_V3.2.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group RVMDK
    ../STM32F10x_StdPeriph_Lib_V3.2.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s
